Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
File name: Projektnummer
Time: 2017-02-22T11:54:52
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 22 11:54:52 2017 * Host: MKlein * Database: C:\Users\mklein\AppData\Local\Temp\{ED58F48A-D033-436A-A629-06D8EF7B400C}\ifc * Database version: 5507 * Database creation date: Wed Feb 22 11:54:52 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 22 11:54:52 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 22 11:54:52 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 48, 8, 20, 852966; RefLongitude: 11, 34, 48, 669204; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Projektname: Projektname; Verfasser Telefon: Telefon; Verfasser PLZ Ort: PLZ Ort; Projektausgabedatum: Projekt Datum; Projektnummer: Projektnummer; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Projektadresse: Projektadresse; Verfasser Firma 2: Firma 2; Projektstatus: Projektstatus; Kundenname: Bauherr; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Abhängigkeiten - Basishöhe: Projekt-Basispunkt; Ansicht: 0 m
Grafiken - Symbol bei Ende 1 Standard: no; Symbol: Beschriftung Ebene: Beschriftung Ebene; Linienmuster: Verdeckt; Linienstärke: 1; Symbol bei Ende 2 Standard: yes; Farbe: 16711680
ID-Daten - Name: Ebene 0; Gebäudegeschoss: yes; Tragwerk: no
Abmessungen - Höhe für Berechnung: 0 m

# IfcBuildingElementProxy: primoSchwank-10, Space_Heater-Schwank-High_Intensity-primoSchwank:primoSchwank-10:330318
In: Ebene 0
Material: Matal - Schwank - Semi - Polished, Matal - Schwank - Copper - Satin Brushed
Phasen - Phase erstellt: Phase 1
Abhängigkeiten - Versatz: 0 m; Ebene: Ebene: Ebene 0; Rear Clearance to Combustibles: Dimension F; Front Clearance to Combustibles: Dimension D; Bottom Clearance to Combustibles: Dimension G; Basisbauteil: Ebene : Ebene 0; Top Clearance to Combustibles: Dimension E
HLS - Systemklassifizierung: Energie,Sonstige; Radiant Efficiency: 65.6%; Thermal Efficiency: >85%; IR Output: 7033.71 W; Natural Gas: yes; Rating Natural Gas: 10990.2 W; Liquid Propane: no; Gas Pressure WC Manifold: 5; Gas Pressure Line WC Minimum: 6; Gas Pressure Line WC Maximum: 14; Gas Inlet Radius: 0.00635 m
ID-Daten - Kennzeichen: 1; Manufacturer Address: 2 Schwank Way, Waynesboro, GA 30830; Weight: 342.957; Modell: primoSchwank- 10; Hersteller: Schwank; Manufacturer Email: mailto:csr@schwankgroup.com; Cost Info: mailto:csr@schwankgroup.com; Beschreibung: High Intensity Heaters, primoSchwank- 10; Manufacturer Phone: 1-877-446-3727; OmniClass-Titel: Fuel-Fired Radiant Heaters; Manufacturer Fax: 1-866-724-9265; Baugruppenbeschreibung: Heat Generating Systems; Subcategory: High Intensity Heaters; Product Page URL: http://www.schwankusa.com/high-intensity-heaters/primo/; URL: http://www.schwankusa.com; Manufacturer Phone - Toll Free: 1-877-446-3727; Baugruppenkennzeichen: D3020; 95 CSI: 15768; OmniClass-Nummer: 23.75.10.17.14.14; 04 CSI: 23 83 33
Sonstige - Angle Control: 30 deg; Dimension A: 0.4064 m; Dimension F: 1.7018 m; Dimension D: 0.2032 m; Base: no; Dimension B: 0.762 m; Dimension G: 1.7018 m; Dimension E: 0.6096 m; Dimension C: 2.286 m; Box Width C: 0.594868 m
Abmessungen - Angle: 30 deg; Width: 0.508 m; Overall Length with Controls: 0.860298 m; Heater Box Length: 0.606298 m; Minimum Mounting Height: 4.572 m; Height: 0.295275 m
Pset_ManufacturerTypeInformation - Manufacturer: Schwank
Pset_BuildingElementProxyCommon - Reference: primoSchwank-10
Elektro - Lasten - Power Factor: 1; Voltage: 0; Load Classification: Power; Load Sub Classification Motor: no; Apparent Load: 0; Number of Poles: 1
Text - Technical Information: http://www.schwankusa.com/fileadmin/pdf/Tech_Specs/High_Intensity/primo_Tech_Specs_TS090921_RL-01B.pdf; Warranty URL: http://www.schwankusa.com/fileadmin/pdf/Forms/Schwank_Warranty_Summary_Nov-2012.pdf; Manual URL: http://www.schwankusa.com/fileadmin/pdf/Manuals/High_Intensity_Heaters/supra_primo_Manual_12C_NOV-2011.pdf; Brochure URL: http://www.schwankusa.com/fileadmin/pdf/Schwank%20Literature/Product_Brochures/primoSchwank%20October%2024.pdf
Elektro - Control Amperage: 0.55; Control Voltage: 258.334; Control Frequency: 60
Materialien und Oberflächen - Heater: Matal - Schwank - Copper - Satin Brushed; Unit: Matal - Schwank - Semi - Polished
Eigenschaften für ökologisches Bauen - ecoScorecard Product Page: http://ecoscorecard.com/
Konstruktion - Gas Inlet Connector: Gas Inlet Connector

# IfcBuildingElementProxy: primoSchwank-15, Space_Heater-Schwank-High_Intensity-primoSchwank:primoSchwank-15:330331
In: Ebene 0
Material: Matal - Schwank - Semi - Polished, Matal - Schwank - Copper - Satin Brushed
Abhängigkeiten - Bottom Clearance to Combustibles: Dimension G; Ebene: Ebene: Ebene 0; Top Clearance to Combustibles: Dimension E; Basisbauteil: Ebene : Ebene 0; Rear Clearance to Combustibles: Dimension F; Front Clearance to Combustibles: Dimension D; Versatz: 0 m
ID-Daten - Kennzeichen: 2; Hersteller: Schwank; Weight: 490.355; OmniClass-Titel: Fuel-Fired Radiant Heaters; Manufacturer Address: 2 Schwank Way, Waynesboro, GA 30830; Baugruppenbeschreibung: Heat Generating Systems; Manufacturer Email: mailto:csr@schwankgroup.com; Manufacturer Fax: 1-866-724-9265; 95 CSI: 15768; OmniClass-Nummer: 23.75.10.17.14.14; Beschreibung: High Intensity Heaters, primoSchwank- 15; Manufacturer Phone: 1-877-446-3727; 04 CSI: 23 83 33; Baugruppenkennzeichen: D3020; Product Page URL: http://www.schwankusa.com/high-intensity-heaters/primo/; URL: http://www.schwankusa.com; Manufacturer Phone - Toll Free: 1-877-446-3727; Modell: primoSchwank- 15; Cost Info: mailto:csr@schwankgroup.com; Subcategory: High Intensity Heaters
Phasen - Phase erstellt: Phase 1
HLS - Systemklassifizierung: Energie,Sonstige; Thermal Efficiency: >85%; Gas Pressure Line WC Maximum: 14; IR Output: 10374.7 W; Gas Inlet Radius: 0.00635 m; Liquid Propane: no; Natural Gas: yes; Gas Pressure Line WC Minimum: 6; Radiant Efficiency: 63.2%; Gas Pressure WC Manifold: 5; Rating Natural Gas: 16412 W
Abmessungen - Angle: 30 deg; Width: 0.508 m; Heater Box Length: 0.8763 m; Height: 0.295275 m; Minimum Mounting Height: 5.4864 m; Overall Length with Controls: 1.1303 m
Sonstige - Angle Control: 30 deg; Box Width C: 0.86487 m; Dimension C: 2.54 m; Dimension D: 0.2032 m; Dimension G: 1.778 m; Dimension F: 1.778 m; Dimension A: 0.4572 m; Base: no; Dimension E: 0.6096 m; Dimension B: 0.9144 m
Pset_ManufacturerTypeInformation - Manufacturer: Schwank
Pset_BuildingElementProxyCommon - Reference: primoSchwank-15
Text - Brochure URL: http://www.schwankusa.com/fileadmin/pdf/Schwank%20Literature/Product_Brochures/primoSchwank%20October%2024.pdf; Warranty URL: http://www.schwankusa.com/fileadmin/pdf/Forms/Schwank_Warranty_Summary_Nov-2012.pdf; Technical Information: http://www.schwankusa.com/fileadmin/pdf/Tech_Specs/High_Intensity/primo_Tech_Specs_TS090921_RL-01B.pdf; Manual URL: http://www.schwankusa.com/fileadmin/pdf/Manuals/High_Intensity_Heaters/supra_primo_Manual_12C_NOV-2011.pdf
Elektro - Lasten - Load Classification: Power; Apparent Load: 0; Load Sub Classification Motor: no; Power Factor: 1; Number of Poles: 1; Voltage: 0
Konstruktion - Gas Inlet Connector: Gas Inlet Connector
Materialien und Oberflächen - Unit: Matal - Schwank - Semi - Polished; Heater: Matal - Schwank - Copper - Satin Brushed
Elektro - Control Frequency: 60; Control Amperage: 0.55; Control Voltage: 258.334
Eigenschaften für ökologisches Bauen - ecoScorecard Product Page: http://ecoscorecard.com/

# IfcBuildingElementProxy: primoSchwank-20, Space_Heater-Schwank-High_Intensity-primoSchwank:primoSchwank-20:330344
In: Ebene 0
Material: Matal - Schwank - Semi - Polished, Matal - Schwank - Copper - Satin Brushed
Abhängigkeiten - Rear Clearance to Combustibles: Dimension F; Front Clearance to Combustibles: Dimension D; Bottom Clearance to Combustibles: Dimension G; Ebene: Ebene: Ebene 0; Versatz: 0 m; Top Clearance to Combustibles: Dimension E; Basisbauteil: Ebene : Ebene 0
ID-Daten - Kennzeichen: 3; Manufacturer Email: mailto:csr@schwankgroup.com; Manufacturer Phone - Toll Free: 1-877-446-3727; Modell: primoSchwank- 20; Hersteller: Schwank; Manufacturer Address: 2 Schwank Way, Waynesboro, GA 30830; Baugruppenkennzeichen: D3020; OmniClass-Nummer: 23.75.10.17.14.14; URL: http://www.schwankusa.com; OmniClass-Titel: Fuel-Fired Radiant Heaters; Baugruppenbeschreibung: Heat Generating Systems; Manufacturer Phone: 1-877-446-3727; 95 CSI: 15768; Cost Info: mailto:csr@schwankgroup.com; Beschreibung: High Intensity Heaters, primoSchwank- 20; Product Page URL: http://www.schwankusa.com/high-intensity-heaters/primo/; Weight: 588.134; Subcategory: High Intensity Heaters; Manufacturer Fax: 1-866-724-9265; 04 CSI: 23 83 33
Abmessungen - Angle: 30 deg; Heater Box Length: 1.15878 m; Height: 0.295275 m; Minimum Mounting Height: 6.096 m; Width: 0.508 m; Overall Length with Controls: 1.41278 m
Phasen - Phase erstellt: Phase 1
HLS - Systemklassifizierung: Energie,Sonstige; Rating Natural Gas: 21980.3 W; IR Output: 14375.1 W; Radiant Efficiency: 65.4%; Gas Pressure WC Manifold: 5; Gas Pressure Line WC Minimum: 6; Gas Inlet Radius: 0.00635 m; Thermal Efficiency: >85%; Natural Gas: yes; Liquid Propane: no; Gas Pressure Line WC Maximum: 14
Sonstige - Angle Control: 30 deg; Dimension E: 0.6096 m; Dimension D: 0.2032 m; Box Width C: 1.14735 m; Dimension G: 1.778 m; Dimension A: 0.4572 m; Dimension C: 2.54 m; Dimension B: 0.9144 m; Dimension F: 1.778 m; Base: no
Pset_ManufacturerTypeInformation - Manufacturer: Schwank
Pset_BuildingElementProxyCommon - Reference: primoSchwank-20
Eigenschaften für ökologisches Bauen - ecoScorecard Product Page: http://ecoscorecard.com/
Elektro - Control Amperage: 0.55; Control Voltage: 258.334; Control Frequency: 60
Elektro - Lasten - Voltage: 0; Apparent Load: 0; Load Classification: Power; Number of Poles: 1; Power Factor: 1; Load Sub Classification Motor: no
Materialien und Oberflächen - Unit: Matal - Schwank - Semi - Polished; Heater: Matal - Schwank - Copper - Satin Brushed
Text - Warranty URL: http://www.schwankusa.com/fileadmin/pdf/Forms/Schwank_Warranty_Summary_Nov-2012.pdf; Brochure URL: http://www.schwankusa.com/fileadmin/pdf/Schwank%20Literature/Product_Brochures/primoSchwank%20October%2024.pdf; Technical Information: http://www.schwankusa.com/fileadmin/pdf/Tech_Specs/High_Intensity/primo_Tech_Specs_TS090921_RL-01B.pdf; Manual URL: http://www.schwankusa.com/fileadmin/pdf/Manuals/High_Intensity_Heaters/supra_primo_Manual_12C_NOV-2011.pdf
Konstruktion - Gas Inlet Connector: Gas Inlet Connector

# IfcBuildingElementProxy: primoSchwank-30, Space_Heater-Schwank-High_Intensity-primoSchwank:primoSchwank-30:330357
In: Ebene 0
Material: Matal - Schwank - Semi - Polished, Matal - Schwank - Copper - Satin Brushed
Materialien und Oberflächen - Heater: Matal - Schwank - Copper - Satin Brushed; Unit: Matal - Schwank - Semi - Polished
Konstruktion - Gas Inlet Connector: Gas Inlet Connector
Text - Manual URL: http://www.schwankusa.com/fileadmin/pdf/Manuals/High_Intensity_Heaters/supra_primo_Manual_12C_NOV-2011.pdf; Brochure URL: http://www.schwankusa.com/fileadmin/pdf/Schwank%20Literature/Product_Brochures/primoSchwank%20October%2024.pdf; Technical Information: http://www.schwankusa.com/fileadmin/pdf/Tech_Specs/High_Intensity/primo_Tech_Specs_TS090921_RL-01B.pdf; Warranty URL: http://www.schwankusa.com/fileadmin/pdf/Forms/Schwank_Warranty_Summary_Nov-2012.pdf
ID-Daten - Beschreibung: High Intensity Heaters, primoSchwank- 30; Baugruppenbeschreibung: Heat Generating Systems; Cost Info: mailto:csr@schwankgroup.com; Weight: 801.205; 04 CSI: 23 83 33; Manufacturer Phone: 1-877-446-3727; Subcategory: High Intensity Heaters; Baugruppenkennzeichen: D3020; OmniClass-Titel: Fuel-Fired Radiant Heaters; Modell: primoSchwank- 30; Manufacturer Fax: 1-866-724-9265; Manufacturer Email: mailto:csr@schwankgroup.com; Hersteller: Schwank; 95 CSI: 15768; Manufacturer Phone - Toll Free: 1-877-446-3727; OmniClass-Nummer: 23.75.10.17.14.14; URL: http://www.schwankusa.com; Product Page URL: http://www.schwankusa.com/high-intensity-heaters/primo/; Manufacturer Address: 2 Schwank Way, Waynesboro, GA 30830; Kennzeichen: 4
Elektro - Lasten - Number of Poles: 1; Load Sub Classification Motor: no; Power Factor: 1; Load Classification: Power; Apparent Load: 0; Voltage: 0
Abhängigkeiten - Front Clearance to Combustibles: Dimension D; Bottom Clearance to Combustibles: Dimension G; Versatz: 0 m; Top Clearance to Combustibles: Dimension E; Basisbauteil: Ebene : Ebene 0; Rear Clearance to Combustibles: Dimension F; Ebene: Ebene: Ebene 0
HLS - Systemklassifizierung: Energie,Sonstige; Liquid Propane: no; Gas Inlet Radius: 0.00635 m; Natural Gas: yes; Gas Pressure Line WC Maximum: 14; Gas Pressure Line WC Minimum: 6; IR Output: 22.4199 W; Thermal Efficiency: >85%; Radiant Efficiency: 67.7%; Gas Pressure WC Manifold: 5; Rating Natural Gas: 33117 W
Phasen - Phase erstellt: Phase 1
Sonstige - Angle Control: 30 deg; Base: no; Dimension G: 1.8796 m; Dimension F: 1.8796 m; Dimension A: 0.4572 m; Dimension E: 0.6096 m; Dimension C: 2.667 m; Box Width C: 1.69851 m; Dimension D: 0.2032 m; Dimension B: 1.0668 m
Abmessungen - Angle: 30 deg; Overall Length with Controls: 1.96394 m; Width: 0.508 m; Height: 0.295275 m; Minimum Mounting Height: 7.3152 m; Heater Box Length: 1.70994 m
Pset_ManufacturerTypeInformation - Manufacturer: Schwank
Pset_BuildingElementProxyCommon - Reference: primoSchwank-30
Elektro - Control Frequency: 60; Control Voltage: 258.334; Control Amperage: 0.55
Eigenschaften für ökologisches Bauen - ecoScorecard Product Page: http://ecoscorecard.com/
